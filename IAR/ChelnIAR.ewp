# IAR project ChelnIAR.ewp, settings and files
configuration Debug (AVR, debug)
configuration Release (AVR)
  as the first configuration, except:
  group (top)
    ./: main.c
